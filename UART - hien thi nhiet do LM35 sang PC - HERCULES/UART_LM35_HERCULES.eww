<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\UART_LM35_HERCULES.ewp</path>
  </project>
  <batchBuild/>
</workspace>


